Commit message: 0917test ok on desk

File: robot_urdf/urdf/uav2.urdf (robot description, URDF)
Before this commit: robot robot_urdf, 8 links, 7 joints
Joints:
- joint revolute_joint_4: origin xyz=0 0 0.026516 rpy=1.5708 -1.5708 0 -> xyz=0 0 0.026516 rpy=-1.5708 -1.5708 0
